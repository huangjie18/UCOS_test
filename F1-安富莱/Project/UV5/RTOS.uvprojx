# Keil uVision project RTOS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\STM32F10x_StdPeriph_Driver\inc;..\..\User;..\..\User\OS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../User/: main.c
  group StdPerph_Driver
    ../../STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c
  group bsp
    ../../User/OS/: bsp_timer.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
